# IAR project Backup of bbs.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  ICCARM.CCIncludePath2: ; ..\include\; app; in_serial; l
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: bbs.bin
  ILINK.IlinkOutputFile: bbs.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: NDEBUG; __PROG_APP_USE__; __WATCHDOG_ENABLE__
  ICCARM.CCIncludePath2: ; ..\include\; app; in_serial
  ILINK.IlinkIcfFile: stm32f10x_flash_app.icf
  group Include
    ../include/: cortexm3_macro.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_lib.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_RTC.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_systick.h stm32f10x_tim.h stm32f10x_type.h stm32f10x_usart.h stm32f10x_wwdg.h
  group Module
    ../module/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ./: bit_define.h cortexm3_macro.s main.c main.h stm32f10x_conf.h stm32f10x_flash.icf stm32f10x_flash_app.icf stm32f10x_init.c stm32f10x_init.h stm32f10x_it.c stm32f10x_it.h stm32f10x_vector.c
  group User/App
    app/: 24lcxx.c 24lcxx.h buzzer.c buzzer.h ebds_exec.c ebds_exec.h eeprom.c eeprom.h iexec.c iexec.h iexio.c iexio.h m25sf.c m25sf.h mecha.c mecha.h sf_m25pxx.c sf_m25pxx.h sfc.c sfc.h
  group User/Serial
    In_serial/: crc.c ex_uart0.c ex_uart1.c ex_uart2.c ex_uart3.c pc2uart.c uart1.c uart1.h uart3.c uart3.h uart4.c uart4.h uart5.c uartx.c
    in_serial/: crc.h ex_uart0.h ex_uart1.h ex_uart2.h ex_uart3.h pc2uart.h uart5.h uartx.h
